# Keil uVision project i2c.uvproj, settings and files
target LPC (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: i2c +hex
  c flags: Optim=1
  c include: ..\i2c;.\CM3\CoreSupport;.\CM3\DeviceSupport\NXP\LPC177x_8x;.\driver;.\main
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ./: startup_LPC177x_8x.s
  group CMSIS
    ./CM3/CoreSupport/: core_cm3.c
    ./CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
  group drivers
    ./driver/: LPC177x_8x_i2c.c LPC177x_8x_uart.c ADXL345.c BMP085.c HMC5883L.c L3G4200D.c LPC177x_8x_timer.c
  group main
    ./main/: main.c
